Commit message: SLAM

File: description/robot_core.xacro (robot description, xacro)
@@ -26,4 +26,6 @@
         <origin xyz="0 0 0" rpy="0 0 0"/>
     </joint>
+    <link name="base_footprint">
+    </link>
     <!-- CHASSIS LINK-->
     <joint name="chassis_joint" type="fixed">
